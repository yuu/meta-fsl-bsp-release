# Copyright (C) 2013 Freescale Semiconductor
include hdcp-app.inc

LIC_FILES_CHKSUM = "file://EULA.txt;md5=93b784b1c11b3fffb1638498a8dde3f6"

PE = "1"

SRC_URI[md5sum] = "b0b53a087ec4374b5467bb2d8afcd623"
SRC_URI[sha256sum] = "8e07c2b8501b66909e2da94e1581e42997e6e252c0246c0ddeffd9cf6fc1e2b7"

COMPATIBLE_MACHINE = "(mx6)"
