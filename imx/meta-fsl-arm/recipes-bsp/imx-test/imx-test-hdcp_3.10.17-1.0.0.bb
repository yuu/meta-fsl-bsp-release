# Copyright (C) 2013 Freescale Semiconductor
include imx-test-hdcp.inc

LIC_FILES_CHKSUM = "file://EULA.txt;md5=93b784b1c11b3fffb1638498a8dde3f6"

SRC_URI[md5sum] = "7289f732beac67c50a1857d86e43c6eb"
SRC_URI[sha256sum] = "a64075953103da6a06714bdacb3bfa43845c2bd304d1cd00b5443d3edf02d904"

COMPATIBLE_MACHINE = "(mx6)"
