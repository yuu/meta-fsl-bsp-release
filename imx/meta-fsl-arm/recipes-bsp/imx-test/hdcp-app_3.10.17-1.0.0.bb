# Copyright (C) 2013 Freescale Semiconductor
include hdcp-app.inc

LIC_FILES_CHKSUM = "file://EULA.txt;md5=93b784b1c11b3fffb1638498a8dde3f6"

PE = "1"

SRC_URI[md5sum] = "be3534e716973df59eb10bbe40a7d53d"
SRC_URI[sha256sum] = "6558dfb54aa0337b27e527de1cc9f9adece70be93f408679e9fc4d2f93e42938"

COMPATIBLE_MACHINE = "(mx6)"
