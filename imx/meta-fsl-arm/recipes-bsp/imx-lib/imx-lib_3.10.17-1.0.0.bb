# Copyright (C) 2013-14 Freescale Semiconductor

require recipes-bsp/imx-lib/imx-lib.inc

SRC_URI[md5sum] = "8e3346d5f33b5aa5f915a0dd8aa99cc9"
SRC_URI[sha256sum] = "f42605971977e5fe1ed9e7ce17ea3f97586a23fbc60fa0f679940d379c72303e"

PE = "1"

COMPATIBLE_MACHINE = "(mx6)"
